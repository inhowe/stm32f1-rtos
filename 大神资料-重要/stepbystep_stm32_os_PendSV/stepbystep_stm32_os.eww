<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\template\template.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test_1\test1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


