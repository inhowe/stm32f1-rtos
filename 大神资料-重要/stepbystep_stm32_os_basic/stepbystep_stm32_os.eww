<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test_2\test2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


